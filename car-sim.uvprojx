# Keil uVision project car-sim.uvprojx, settings and files
target DISCO_L475 (6220000::V6.22::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: car-sim
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\VIO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Core/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Core/Inc/: stm32l4xx_it.h
  group VIO
    ./VIO/: vio_BL475EIOT01A.c
software components: CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Drivers:Accelerometer 1.1.6, Board Support:Drivers:Basic I/O 1.1.6, Board Support:Drivers:Gyroscope 1.1.6, Board Support:Drivers:Humidity Sensor 1.1.6, Board Support:Drivers:Magnetometer 1.1.6, Board Support:Drivers:Pressure Sensor 1.1.6, Board Support:Drivers:Temperature Sensor 1.1.6, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.13.4, Device:STM32Cube HAL:Cortex 1.13.4, Device:STM32Cube HAL:DFSDM 1.13.4, Device:STM32Cube HAL:DMA 1.13.4, Device:STM32Cube HAL:GPIO 1.13.4, Device:STM32Cube HAL:I2C 1.13.4, Device:STM32Cube HAL:PCD 1.13.4, Device:STM32Cube HAL:PWR 1.13.4, Device:STM32Cube HAL:QSPI 1.13.4, Device:STM32Cube HAL:RCC 1.13.4, Device:STM32Cube HAL:SPI 1.13.4, Device:STM32Cube HAL:UART 1.13.4, Device:STM32Cube LL:Common 1.13.4, Device:STM32Cube LL:PWR 1.13.4, Device:STM32Cube LL:RCC 1.13.4, Device:STM32Cube LL:USB 1.13.4, Device:STM32Cube LL:UTILS 1.13.4, Device:Startup 1.3.2
